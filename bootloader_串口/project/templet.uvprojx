# Keil uVision project templet.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F205ZGTx STMicroelectronics
  pack: Keil.STM32F2xx_DFP.2.9.0
  cpu: IROM(0x08000000,0x00100000) IRAM(0x20000000,0x00020000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: templet
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: ..\Libraries\CMSIS\CM3\CoreSupport;..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F2xx;..\Libraries\STM32F2xx_StdPeriph_Driver\inc;..\user;..\app\Delay;..\Libraries\STM32F2xx_StdPeriph_Driver\src;..\app;..\bootloader
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Lib
    ../Libraries/STM32F2xx_StdPeriph_Driver/src/: misc.c stm32f2xx_flash.c stm32f2xx_gpio.c stm32f2xx_rcc.c stm32f2xx_tim.c stm32f2xx_usart.c
  group User
    ../user/: main.c stm32f2xx_it.c
  group CMSIS
    ../Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F2xx/: system_stm32f2xx.c
  group Startup
    ../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F2xx/startup/arm/: startup_stm32f2xx.s
  group app
    ../app/: delay.c iap.c stmflash.c sys.c usart.c
  group bootloader
    ../bootloader/: bootloader.c
